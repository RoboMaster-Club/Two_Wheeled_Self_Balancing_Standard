# Keil uVision project Self Balancing Standard Robot 2022 Leo.uvprojx, settings and files
target Self Balancing Standard Robot 2022 Leo (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Self Balancing Standard Robot 2022 Leo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,ARM_MATH_DSP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Devices/Devices.h;../Algorithms/Algorithms.h;../BSP/BSP.h;../HigherLevelApps/HigherLevelApps.h;../ui/inc
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HigherLevelApps
    ../HigherLevelApps/HigherLevelApps.c/: Chassis_Control.c IMU_Temp_Control.c Robot_Control.c State_Machine.c Gimbal_Control.c Shooting_Control.c
  group Algorithms
    ../Algorithms/Algorithms.c/: PID.c Ramp_Calc.c User_Defined_Math.c Control_Strategy.c Kalman_Filter.c
  group Devices
    ../Devices/Devices.c/: Board_A_IMU.c Buzzer.c DR16_Remote.c MF9025_Motor.c M3508_Motor.c GM6020_Motor.c M2006_Motor.c Referee_System.c Super_Capacitor.c Control_Board_A.c Jetson_Tx2.c
  group BSP
    ../BSP/BSP.c/: CAN_Setup.c CRC_Verification.c FusionAhrs.c FusionCompass.c FusionOffset.c I2C_Setup.c
  group UI
    ../ui/src/: ui_indicator_0_0.c ui_indicator_0_1.c ui_indicator_0_2.c ui_indicator_0_3.c ui_indicator_0_4.c ui_indicator_0_5.c ui_indicator_0_6.c ui_indicator_0_7.c ui_indicator_0_8.c ui_indicator_0_9.c ui_indicator_0_10.c ui_indicator_0_11.c ui_indicator_1_0.c ui_indicator_1_1.c ui_interface.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
